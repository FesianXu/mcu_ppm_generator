# Keil uVision project proj.uvprojx, settings and files
target target (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: proj +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\USER;.\stm32f10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\usart;.\SYSTEM\sys;.\Hardware_driver\ppm;.\Hardware_driver\remote_ctrl;.\Software\ppm_parser
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group Software
    ./Software/ppm_parser/: ppm_parser.c
  group Hardware_driver
    ./Hardware_driver/ppm/: ppm.c
    ./Hardware_driver/remote_ctrl/: remote_ctrl.c
  group FWLib
    ./stm32f10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
